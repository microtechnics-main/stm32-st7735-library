<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MT_ST7735_Example.ewp</path>
  </project>
  <batchBuild />
</workspace>
